Commit message: code with centralized pd controller

File: plan_control/urdf/caminante_minimal_gen.urdf (robot description, URDF)
Before this commit: robot caminante, 11 links, 10 joints
Links:
- link pelvis: mass 6.4909068 -> 3.4909068
